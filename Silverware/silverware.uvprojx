# Keil uVision project silverware.uvprojx, settings and files
target NFE_SILVERWARE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NFE_SILVERWARE +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F031
  c misc: --fpmode=fast
  c include: .\src ; ..\; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc;  ..\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: control.c main.c buzzer.c flash.c gestures.c gesture_detect.c rx_bayang_protocol.c rx_bayang_protocol_ble.c rx_bayang_ble_app.c rx_bayang_protocol_telemetry.c rx_nrf24_bayang_telemetry.c rx_sbus.c rx_crsf.c rx_dsm.c led.c rgb_led.c sixaxis.c motorcurve.c util.c stickvector.c imu.c flip_sequencer.c filter.cpp angle_pid.c pid.c defines.h hardware.h config.h debug.h drv_softserial.c serial_4way.c serial_4way_stk500v2.c serial_4way_avrootloader.c rx_bayang_protocol_telemetry_autobind.c uart.h rx_ibus.c
  group drv
    ./src/: drv_adc.c drv_clk.c drv_fmc1.c drv_fmc2.c drv_gpio.c drv_i2c.c drv_pwm.c drv_esc.c drv_dshot.c drv_serial.c drv_softi2c.c drv_spi.c drv_spi_3wire.c drv_spi_none.c drv_time.c drv_xn297_3wire.c drv_xn297.c drv_hw_i2c.c drv_rgb.c drv_dshot_dma.c drv_rx_serial.c drv_rx_serial.h
  group StartupSTM32F0
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f031.s
  group PeripheralsSTM32F0
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SystemInitSTM32F0
    ../Utilities/: system_stm32f0xx.c
  group StartupSTM32F4
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
  group PeripheralsSTM32F4
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SystemInitSTM32F4
    ../Utilities/F4_HSE/: system_stm32f4xx.c
target QUICKSILVERF4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QUICKSILVERF4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx
  c misc: --fpmode=fast
  c include: .\src;.\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\Utilities\;.\..\Libraries\CMSIS\CM4\CoreSupport;.\..\Libraries\CMSIS\CM4\Include;.\..\Libraries\CMSIS\CM4\DeviceSupport\ST\STM32F4xx;.\..\Libraries\CMSIS\CM4\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
